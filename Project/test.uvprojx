# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,USE_USB_OTG_FS
  c include: ..\Libraries\CMSIS;..\Libraries\FWLib\inc;..\User;..\User\Global;..\User\MALLOC;..\User\FATFS\src;..\User\FATFS\exfuns;..\User\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\User\USB\STM32_USB_HOST_Library\Core\inc;..\User\USB\STM32_USB_OTG_Driver\inc;..\User\USB\USB_APP;..\User\BSP\USART;..\User\lwIP\src\include;..\User\lwIP\src;..\User\lwIP\src\arch;..\User\BSP\TM1637;..\User\BSP\Key;..\User\APP\TFTP_Server;..\User\APP\UDP_Trigger;..\User\APP\TCP_Sniffer;..\User\APP\Display
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h MCU_NetworkInterface.c MCU_Display.c
  group APP
    ../User/APP/TFTP_Server/: tftp_server.c
    ../User/APP/UDP_Trigger/: udp_trigger.c
    ../User/APP/TCP_Sniffer/: tcp_sniffer.c
    ../User/APP/Display/: display.c
  group BSP
    ../User/BSP/USART/: usart1.c
    ../User/BSP/TM1637/: tm1637.c
    ../User/BSP/Key/: key.c
  group Global
    ../User/Global/: global.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
  group FWLib
    ../Libraries/FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c
  group MALLOC
    ../User/MALLOC/: malloc.c
  group FATFS
    ../User/FATFS/src/: diskio.c ff.c
    ../User/FATFS/exfuns/: mycc936.c exfuns.c
  group USB_OTG
    ../User/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../User/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../User/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../User/USB/USB_APP/: usb_bsp.c usbh_usr.c
  group lwIP - arch
    ../User/lwIP/src/arch/: cc.h lwipopts.h perf.h
    ../User/lwIP/src/arch/ENC28J60/: spi1.c enc28j60.c
    ../User/lwIP/src/arch/Timer/: timer7.c
  group lwIP - netif
    ../User/lwIP/src/netif/: ethernet.c ethernetif.c
  group lwIP - core
    ../User/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwIP - core - ip4
    ../User/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
